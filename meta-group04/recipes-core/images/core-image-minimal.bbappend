
# imported and base recipes
IMAGE_INSTALL_append = "\
    hello \
    "

